# Keil uVision project NewProject.uvprojx, settings and files
target NweProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NewProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --locale=english
  c include: ..\CMSIS;..\STM32F4xx_StdPeriph_Driver\inc;..\USER\LED;..\USER\KEY;..\USER\SYSTICK;..\USER\BEEP;..\USER\STERILIZE;..\USER\USART1;..\USER\PWM;..\USER\RGB;..\USER\IIC;..\USER\W25QXX;..\USER\SPI;..\USER\LCD;..\USER\SHT30;..\USER\MLX90614;..\USER\SDCard;..\ff11a\src;..\USER\malloc;..\USER\WAV_Play;..\USER\scan_dir;..\USER\USART3;..\USER\USART2;..\USER\ESP8266;..\uCOS-II\Source;..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\USER\LVGL\app;..\USER\LVGL\porting;..\USER\LVGL\src;..\USER\LVGL;..\USER\TIM;..\generated;..\generated\guider_customer_fonts;..\generated\guider_fonts;..\generated\images;..\custom;..\USER\Motor;..\USER\ADC;..\USER\RTC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group PROJECT
    ./: main.c
  group USER
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/SYSTICK/: systick.c
    ../USER/BEEP/: beep.c
    ../USER/STERILIZE/: sterilize.c
    ../USER/USART1/: usart1.c
    ../USER/PWM/: pwm.c
    ../USER/RGB/: rgb.c
    ../USER/SHT30/: sht30.c
    ../USER/IIC/: iic.c
    ../USER/LCD/: lcd.c
    ../USER/SPI/: spi.c
    ../USER/W25QXX/: w25qxx.c
    ../USER/MLX90614/: mlx90614.c
    ../USER/SDCard/: sd_driver.c
    ../USER/malloc/: malloc.c
    ../USER/scan_dir/: scanf_dir.c
    ../USER/USART3/: usart3.c
    ../USER/USART2/: usart2.c
    ../USER/ESP8266/: esp8266.c
    ../USER/TIM/: tim7.c
    ../USER/font/: zz16.c
    ./: yahei.c
    ../USER/Motor/: motor.c
    ../USER/ADC/: adc.c
    ../USER/RTC/: rtc.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group FATFS
    ../ff11a/src/: diskio.c ff.c
    ../ff11a/src/option/: cc936.c
  group WAV_PLAY
    ../USER/WAV_Play/: i2s.c wav.c wm8978.c wmiic.c
  group UCOS-II
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-PORT
    ../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group LVGL_SRC
    ../USER/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../USER/LVGL/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../USER/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../USER/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../USER/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../USER/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../USER/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../USER/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../USER/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../USER/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../USER/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../USER/LVGL/src/extra/widgets/led/: lv_led.c
    ../USER/LVGL/src/extra/widgets/list/: lv_list.c
    ../USER/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../USER/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../USER/LVGL/src/extra/widgets/span/: lv_span.c
    ../USER/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../USER/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../USER/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../USER/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../USER/LVGL/src/extra/widgets/win/: lv_win.c
    ../USER/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../USER/LVGL/src/extra/: lv_extra.c
    ../USER/LVGL/src/gpu/: lv_gpu_stm32_dma2d.c
    ../USER/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../USER/LVGL/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../USER/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_PORT
    ../USER/LVGL/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group LVGL_APP
    ../USER/LVGL/app/: LVGL_APP.c
  group LVGL_GUI
    ../generated/guider_fonts/: lv_font_simsun_16.c lv_font_simsun_12.c
    ../generated/: events_init.c gui_guider.c setup_scr_screen.c
    ../custom/: custom.c
