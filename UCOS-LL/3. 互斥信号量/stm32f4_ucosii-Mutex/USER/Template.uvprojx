# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM,USE_STDPERIPH_DRIVER
  c include: ..\STM32F4xx_StdPeriph_Driver\inc;..\SYSTEM;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\FWLIB\CMSIS\Include;..\HARDWARE\delay;..\HARDWARE\sys;..\HARDWARE\usart;..\EMWIN_Task\TEXT_DISPLAY;..\HARDWARE\SD;..\FATFS\src;..\FATFS\src\option;..\HARDWARE\RTC;..\uCOS-II\Source;..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\RGB;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/FLASH/: spi_flash.c
    ../HARDWARE/LCD/: bsp_lcd.c
    ../HARDWARE/LED/: gpio.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/SD/: sd.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/RGB/: RGB.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FWLIB
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
  group ucosii-Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucosii-port
    ../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
