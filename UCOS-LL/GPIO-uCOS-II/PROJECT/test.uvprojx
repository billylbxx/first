# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Include;..\STM32F4xx_StdPeriph_Driver\inc;..\USER\KEY;..\USER\LED;..\USER\DELAY;..\uCOS-II\Source;..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\USER\SPI;..\USER\Systick;..\USER\W25Qxx;..\USER\ADC;..\USER\Uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/Include/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group PROJECT
    ./: main.c
  group USER
    ../USER/KEY/: key.c
    ../USER/LED/: led.c
    ../USER/SPI/: SPI.c
    ../USER/Systick/: systick.c
    ../USER/W25Qxx/: w25qxx.c
    ../USER/ADC/: adc.c
    ../USER/Uart/: uart.c
  group STM32LIB
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group uCOS-II Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II CPU
    ../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_dbg.c os_cpu_a.asm
