# Keil uVision project NewProject.uvprojx, settings and files
target NweProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NewProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\STM32F4xx_StdPeriph_Driver\inc;..\USER\LED;..\USER\KEY;..\USER\SYSTICK;..\USER\BEEP;..\USER\STERILIZE;..\USER\USART1;..\USER\PWM;..\USER\RGB;..\USER\IIC;..\USER\W25QXX;..\USER\SPI;..\USER\LCD;..\USER\SHT30;..\USER\MLX90614;..\USER\SDCard;..\ff11a\src;..\USER\malloc;..\USER\WAV_Play;..\USER\scan_dir;..\USER\USART3;..\USER\USART2;..\USER\ESP8266;..\uCOS-II\Source;..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\USER\Delay
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group PROJECT
    ./: main.c
  group USER
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/SYSTICK/: systick.c
    ../USER/BEEP/: beep.c
    ../USER/STERILIZE/: sterilize.c
    ../USER/USART1/: usart1.c
    ../USER/PWM/: pwm.c
    ../USER/RGB/: rgb.c
    ../USER/SHT30/: sht30.c
    ../USER/IIC/: iic.c
    ../USER/LCD/: lcd.c
    ../USER/SPI/: spi.c
    ../USER/W25QXX/: w25qxx.c
    ../USER/MLX90614/: mlx90614.c
    ../USER/SDCard/: sd_driver.c
    ../USER/malloc/: malloc.c
    ../USER/scan_dir/: scanf_dir.c
    ../USER/USART3/: usart3.c
    ../USER/USART2/: usart2.c
    ../USER/ESP8266/: esp8266.c
    ../USER/Delay/: delay.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c
  group FATFS
    ../ff11a/src/: diskio.c ff.c
    ../ff11a/src/option/: cc936.c
  group WAV_PLAY
    ../USER/WAV_Play/: i2s.c wav.c wm8978.c wmiic.c
  group UCOS-II
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-PORT
    ../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
