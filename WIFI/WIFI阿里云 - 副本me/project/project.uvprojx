# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\STM32F4xx_StdPeriph_Driver\inc;..\USER\esp8266;..\USER\key;..\USER\led;..\USER\systick;..\USER\usaert2;..\USER\usart1;..\USER\RGB;..\USER\Motor;..\USER\Tim;..\USER\ADC;..\USER\IIC;..\USER\SHT31;..\USER\SPI;..\USER\W25Qxx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group USER
    ./Objects/: main.c
    ../USER/esp8266/: QMsg.c hmacsha1.c esp8266.c
    ../USER/key/: key.c
    ../USER/led/: led.c
    ../USER/systick/: systick.c
    ../USER/usaert2/: usart2.c
    ../USER/usart1/: uart1.c
    ../USER/RGB/: RGB.c
    ../USER/Motor/: motor.c
    ../USER/Tim/: tim3.c
    ../USER/ADC/: adc.c
    ../USER/IIC/: IIC.c
    ../USER/SHT31/: SHT31.c
    ../USER/SPI/: SPI.c
    ../USER/W25Qxx/: w25qxx.c
  group Drive
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_i2c.c
