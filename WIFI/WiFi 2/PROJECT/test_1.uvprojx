# Keil uVision project test_1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CIMSS;..\STDLIB\inc;..\USER\Led;..\USER\Beep;..\USER\Key;..\USER\Uart;..\STDLIB\inc;..\USER\Motor;..\USER\Exti;..\USER\Systick;..\USER\Tim;..\USER\ADC;..\USER\SPI;..\USER\SPI\batch;..\USER\WiFi;..\USER\DMA;..\USER\RGB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CIMSS
    ../CIMSS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group PROJECT
    ./: main.c
  group USER
    ../USER/Led/: led.c
    ../USER/Beep/: Beep.c
    ../USER/Key/: key.c
    ../USER/Uart/: uart.c
    ../USER/Motor/: motor.c
    ../USER/Exti/: exti.c
    ../USER/Systick/: systick.c
    ../USER/Tim/: tim.c tim7.c tim3.c
    ../USER/ADC/: ADC.c
    ../USER/SPI/: SPI.c
    ../USER/WiFi/: usart2.c
    ../USER/DMA/: DMA.c
    ../USER/RGB/: RGB.c
  group STDLIB
    ../STDLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_dma.c
