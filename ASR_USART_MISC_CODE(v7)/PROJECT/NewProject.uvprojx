# Keil uVision project NewProject.uvprojx, settings and files
target NweProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NewProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\STM32F4xx_StdPeriph_Driver\inc;..\USER\LED;..\USER\KEY;..\USER\SYSTICK;..\USER\BEEP;..\USER\STERILIZE;..\USER\USART1;..\USER\PWM;..\USER\RGB;..\USER\IIC;..\USER\W25QXX;..\USER\SPI;..\USER\LCD;..\USER\SHT30;..\USER\MLX90614;..\USER\ADC;..\FreeRTOS_TASK;..\FreeRTOS_CORE\portable\RVDS\ARM_CM4F;..\FreeRTOS_CORE\include;..\ESP12\ESP12;..\ESP12\HMACSHA1;..\ESP12\USART2;..\ASR_MISC\asr\USART3;..\USER\RTC;..\MYMALLOC;..\FATFS\exfuns;..\FATFS\io;..\FATFS\src;..\ASR_MISC\misc;..\IR_LEARN\ir_learn;..\IR_LEARN\UART4;..\ESP12\JSON;..\LVGL_GUI;..\LVGL_GUI\lvgl;..\LVGL_GUI\lval_app;..\LVGL_GUI\lvgl_driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group PROJECT
    ./: main.c
  group USER
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/SYSTICK/: systick.c
    ../USER/BEEP/: beep.c
    ../USER/STERILIZE/: sterilize.c
    ../USER/USART1/: usart1.c
    ../USER/PWM/: pwm.c
    ../USER/RGB/: rgb.c
    ../USER/SHT30/: sht30.c
    ../USER/IIC/: iic.c
    ../USER/LCD/: lcd.c
    ../USER/SPI/: spi.c
    ../USER/W25QXX/: w25qxx.c
    ../USER/MLX90614/: mlx90614.c
    ../USER/ADC/: adc.c
    ../USER/RTC/: rtc.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c
  group FreeRTOS_CORE
    ../FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS_CORE/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS_CORE/portable/MemMang/: heap_4.c
  group FreeRTOS_TASK
    ../FreeRTOS_TASK/: app_task.c
  group ESP12
    ../ESP12/ESP12/: esp12.c
    ../ESP12/HMACSHA1/: hmacsha1.c
    ../ESP12/USART2/: usart2.c
    ../ESP12/JSON/: json.c
  group ASR_MISC
    ../ASR_MISC/asr/USART3/: usart3.c
    ../ASR_MISC/misc/: audioplay.c wavplay.c wm8978.c wmiic.c i2s.c revert.c
  group FATFS
    ../FATFS/io/: sd_driver.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c ffsystem.c ffunicode.c
  group MYMALLOC
    ../MYMALLOC/: mymalloc.c
  group IR_LEARN
    ../IR_LEARN/ir_learn/: ir_learn.c
    ../IR_LEARN/UART4/: uart4.c
  group LVGL_APP
    ../LVGL_GUI/lval_app/: lvgl_gui_app.c
  group LVGL_CORE
    ../LVGL_GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL_GUI/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL_GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c
    ../LVGL_GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL_GUI/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL_GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LVGL_GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL_GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL_GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c
    ../LVGL_GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL_GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL_GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL_GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL_GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL_GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL_GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL_GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL_GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL_GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL_GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL_GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
  group LVGL_PORT
    ../LVGL_GUI/lvgl_driver/: lv_port_disp.c
  group README
    ../: versions.txt readme.txt
